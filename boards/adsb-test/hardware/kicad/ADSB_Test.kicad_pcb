# Repository mummyJane/board_bsp (continued)

## KiCad design boards/adsb-test/hardware/kicad/ADSB_Test.kicad_pcb (continued)

Schematic: charger_battery.kicad_sch, ADSB_Test - Charger Battery

Parts:
BT301: CR1220 (optional); Battery_Panasonic_CR1220-VCN_Vertical_CircularHoles; not fitted
C301, C302: 47nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C303, C304, C305, C306, C307, C310, C311, C312, C313, C314, C316, C317: 10uF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C308, C315: 100nF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C309: 4.7uF 10V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C318: 1nF 50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C319: 1uF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C320, C321: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D301: CHG (amber); LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D302: BAT43W; D_SOD-123
D303: BAT43W; D_SOD-123; not fitted
J301: 2S Li-ion pack (BAT+, GND, NTC); JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
L301: 2.2uH; L_Bourns_SRP7028A_7.3x6.6mm
R301: 8.2k 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R302: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R303: 5.23k 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R304: 30.1k 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R305: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R306: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RS301, RS302: 20m; R_Shunt_1206_Kelvin_HandSolder
TP301: CHG_QON; TestPoint_Pad_D1.5mm
TP302: BAT_PACK; TestPoint_Pad_D1.5mm
TP303: VSYS; TestPoint_Pad_D1.5mm
TP304: VBUS_CHG; TestPoint_Pad_D1.5mm
TP305: VBACKUP; TestPoint_Pad_D1.5mm
U301: BQ25798; Texas_RQM0029A_VQFN-29_4x4mm_P0.4mm
U302: MCP1703 3.0V (2 uA Iq); SOT-23_Handsoldering

Connections:
/Charger Battery/BKP_CELL: BT301.1 (+), D303.2 (A)
/Charger Battery/CHG_BATP: R305.1, U301.18 (BATP)
/Charger Battery/CHG_BTST1: C301.1, U301.4 (BTST1)
/Charger Battery/CHG_BTST2: C302.1, U301.19 (BTST2)
/Charger Battery/CHG_CE: R302.1, U301.13 (~CE)
/Charger Battery/CHG_LED_A: D301.2 (A), R306.2
/Charger Battery/CHG_PMID: C305.1, C306.1, C307.1, C308.1, U301.29 (PMID)
/Charger Battery/CHG_PROG: R301.1, U301.20 (PROG)
/Charger Battery/CHG_QON: TP301.1, U301.12 (~QON)
/Charger Battery/CHG_REGN: C309.1, R303.1, R306.1, U301.5 (REGN), U301.17 (ILIM_HIZ)
/Charger Battery/CHG_SDRV: C318.1, U301.24 (SDRV)
/Charger Battery/CHG_STAT: D301.1 (K), U301.1 (STAT)
/Charger Battery/CHG_SW1: C301.2, L301.1, U301.28 (SW1)
/Charger Battery/CHG_SW2: C302.2, L301.2, U301.26 (SW2)
/Charger Battery/CHG_TS: J301.3, R303.2, R304.1, U301.16 (TS)
/Charger Battery/VBACKUP_LDO: C320.1, D302.2 (A), U302.2 (VO)
/Charger Battery/VBAT_CHG: C316.1, C317.1, RS301.1, U301.22 (BAT), U301.23 (BAT)
/Charger Battery/VSYS_CHG: C310.1, C311.1, C312.1, C313.1, C314.1, C315.1, RS302.1, U301.25 (SYS)
BAT_PACK: J301.1, R305.2, RS301.4, TP302.1
CHG_PD_INT: U301.21 (~INT); also elsewhere on the board
GND: BT301.2 (-), C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, J301.2, R301.2, R302.2, R304.2, U301.10 (ACDRV2), U301.11 (ACDRV1), U301.27 (GND), U302.1 (GND); also elsewhere on the board
I2C_SCL: U301.14 (SCL); also elsewhere on the board
I2C_SDA: U301.15 (SDA); also elsewhere on the board
PM1_CH2_N: RS301.3; also elsewhere on the board
PM1_CH2_P: RS301.2; also elsewhere on the board
PM1_CH3_N: RS302.3; also elsewhere on the board
PM1_CH3_P: RS302.2; also elsewhere on the board
VBACKUP: C321.1, D302.1 (K), D303.1 (K), TP305.1; also elsewhere on the board
VBUS_CHG: C303.1, C304.1, TP304.1, U301.2 (VBUS), U301.3 (VBUS), U301.8 (VAC2), U301.9 (VAC1); also elsewhere on the board
VSYS: C319.1, RS302.4, TP303.1, U302.3 (VI); also elsewhere on the board

Notes on the sheet:
CHARGER: BQ25798 buck-boost 2S charger + power path (I2C 0x6B), PROG 8.2k = 2S / 750 kHz, TS divider 5.23k/30.1k (10k NTC). Pack: 2 x 18650 with its own 2S protection + balancing on J301. RS301 VBAT (PM1 CH2, bidirectional), RS302 VSYS (PM1 CH3). VBACKUP: MCP1703 3.0 V (2 uA) from VSYS -> BAT43W ->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

Schematic: ethernet.kicad_sch, ADSB_Test - Ethernet

Parts:
C801, C803: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C802, C804, C805: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C806: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C807: 470pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C808, C809: 27pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C810: 22nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
FB801: 600R@100MHz; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
J801: HR911105A; RJ45_Hanrun_HR911105A_Horizontal
R801: 12.1k 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R802, R803, R804, R806, R814, R815, R816: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R805: 1.5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R807: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R808, R809, R810, R811: 49.9R 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R812, R813: 270R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP801: ETH_REF_CLK; TestPoint_Pad_D1.5mm
TP802: ETH_1V2; TestPoint_Pad_D1.5mm
U801: LAN8720A; VQFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm_HandSolder
Y801: 25MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering

Connections:
3V3_ETH: C801.1, C802.1, FB801.1, R804.1, R805.1, R806.1, R814.1, R815.1, R816.1, U801.9 (VDDIO); also elsewhere on the board
/Ethernet/ETH_1V2: C806.1, C807.1, TP802.1, U801.6 (VDDCR)
/Ethernet/ETH_AVDD: C803.1, C804.1, C805.1, C810.1, FB801.2, J801.4 (TCT), J801.5 (RCT), R808.1, R809.1, R810.1, R811.1, U801.1 (VDD2A), U801.19 (VDD1A)
/Ethernet/ETH_LED1: R802.1, R812.1, U801.3 (LED1/REGOFF)
/Ethernet/ETH_LED1_K: J801.12, R812.2
/Ethernet/ETH_LED2: R803.1, R813.1, U801.2 (LED2/~INTSEL)
/Ethernet/ETH_LED2_K: J801.9, R813.2
/Ethernet/ETH_RBIAS: R801.1, U801.24 (RBIAS)
/Ethernet/ETH_REFCLKO: R807.1, U801.14 (~INT/REFCLKO)
/Ethernet/ETH_RXER: R804.2, U801.10 (RXER/PHYAD0)
/Ethernet/ETH_RX_N: J801.6 (RD-), R811.2, U801.22 (RXN)
/Ethernet/ETH_RX_P: J801.3 (RD+), R810.2, U801.23 (RXP)
/Ethernet/ETH_TX_N: J801.2 (TD-), R809.2, U801.20 (TXN)
/Ethernet/ETH_TX_P: J801.1 (TD+), R808.2, U801.21 (TXP)
/Ethernet/ETH_XI: C808.1, U801.5 (XTAL1/CLKIN), Y801.1
/Ethernet/ETH_XO: C809.1, U801.4 (XTAL2), Y801.2
ETH_CRS_DV: R816.2, U801.11 (CRS_DV/MODE2); also elsewhere on the board
ETH_MDC: U801.13 (MDC); also elsewhere on the board
ETH_MDIO: R805.2, U801.12 (MDIO); also elsewhere on the board
ETH_PHY_RST: R806.2, U801.15 (~RST); also elsewhere on the board
ETH_REF_CLK: R807.2, TP801.1; also elsewhere on the board
ETH_RXD0: R814.2, U801.8 (RXD0/MODE0); also elsewhere on the board
ETH_RXD1: R815.2, U801.7 (RXD1/MODE1); also elsewhere on the board
ETH_TXD0: U801.17 (TXD0); also elsewhere on the board
ETH_TXD1_BOOT: U801.18 (TXD1); also elsewhere on the board
ETH_TX_EN: U801.16 (TXEN); also elsewhere on the board
GND: C801.2, C802.2, C803.2, C804.2, C805.2, C806.2, C807.2, C808.2, C809.2, C810.2, J801.8, J801.10, J801.11, J801.SH, R801.2, R802.2, R803.2, U801.25 (VSS); also elsewhere on the board

Notes on the sheet:
ETHERNET: LAN8720A 10/100 RMII PHY (replaces the IP101GRI: KiCad symbol, ESP-IDF lan87xx driver, cheap breakouts for Phase 1). 25 MHz crystal; REFCLKO (pin 14) feeds the P4 REF_CLK in (GPIO50) through 33R. Straps: REGOFF=0 (int. 1V2 on), nINTSEL=0 (REFCLKO, 10k pull-down), PHYAD0=1 (address 1), MOD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

Schematic: power_rails.kicad_sch, ADSB_Test - Power Rails

Parts:
C411, C412, C421, C422: 10uF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C413, C415, C423, C425: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C414, C424: 33nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C416, C417, C426, C427: 22uF 10V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C430, C431, C432, C433: 1nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
L411, L421: 4.7uH; L_Bourns_SRP5030T
R411: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R412: 28k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R413: 52.3k 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R414, R424: 10k 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R423: 31.6k 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R430, R431, R432, R433: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RS401: 30m; R_Shunt_1206_Kelvin_HandSolder
RS402, RS403, RS404: 50m; R_Shunt_1206_Kelvin_HandSolder
RS405: 330m; R_Shunt_1206_Kelvin_HandSolder
RS406, RS407: 1R; R_Shunt_1206_Kelvin_HandSolder
RS408, RS409: 2.2R; R_Shunt_1206_Kelvin_HandSolder
SW401: POWER (slide); SW_Slide_SPDT_Angled_CK_OS102011MA1Q
TP401: 5V; TestPoint_Pad_D1.5mm
TP402: 3V3; TestPoint_Pad_D1.5mm
TP403: VSYS; TestPoint_Pad_D1.5mm
TP410: 5V_SDR; TestPoint_Pad_D1.5mm
TP411: 5V_LCD; TestPoint_Pad_D1.5mm
TP412: 3V3_MCU; TestPoint_Pad_D1.5mm
TP413: 3V3_SD; TestPoint_Pad_D1.5mm
TP414: 3V3_ETH; TestPoint_Pad_D1.5mm
TP415: 3V3_GPS; TestPoint_Pad_D1.5mm
TP416: 3V3_M1421; TestPoint_Pad_D1.5mm
TP417: 3V3_PERIPH; TestPoint_Pad_D1.5mm
U411, U421: TPS62933; SOT-583-8_HandSolder
U430, U431, U432, U433: TPS22917; SOT-23-6_Handsoldering

Connections:
3V3: RS401.4, RS404.1, RS405.1, RS406.1, RS407.1, RS408.1, RS409.1, TP402.1; also elsewhere on the board
3V3_BUCK: C426.1, C427.1, L421.2, R423.1, RS401.1
3V3_ETH: R431.2, TP414.1, U431.6 (VOUT); also elsewhere on the board
3V3_GPS: R432.2, TP415.1, U432.6 (VOUT); also elsewhere on the board
3V3_M1421: R433.2, TP416.1, U433.6 (VOUT); also elsewhere on the board
3V3_MCU: RS404.4, TP412.1; also elsewhere on the board
3V3_PERIPH: RS409.4, TP417.1; also elsewhere on the board
3V3_SD: RS405.4, TP413.1; also elsewhere on the board
5V: C416.1, C417.1, L411.2, R413.1, RS402.1, RS403.1, TP401.1
5V_LCD: R430.2, TP411.1, U430.6 (VOUT); also elsewhere on the board
5V_SDR: RS402.4, TP410.1; also elsewhere on the board
/Power Rails/3V3_ETH_SH: RS406.4, U431.1 (VIN)
/Power Rails/3V3_GPS_SH: RS407.4, U432.1 (VIN)
/Power Rails/3V3_M1421_SH: RS408.4, U433.1 (VIN)
/Power Rails/5V_LCD_SH: RS403.4, U430.1 (VIN)
/Power Rails/B3V3_BST: C425.1, U421.6 (BST)
/Power Rails/B3V3_FB: R423.2, R424.1, U421.8 (FB)
/Power Rails/B3V3_SS: C424.1, U421.7 (SS)
/Power Rails/B3V3_SW: C425.2, L421.1, U421.5 (SW)
/Power Rails/B5V_BST: C415.1, U411.6 (BST)
/Power Rails/B5V_FB: R413.2, R414.1, U411.8 (FB)
/Power Rails/B5V_SS: C414.1, U411.7 (SS)
/Power Rails/B5V_SW: C415.2, L411.1, U411.5 (SW)
/Power Rails/CT30: C430.1, U430.4 (CT)
/Power Rails/CT31: C431.1, U431.4 (CT)
/Power Rails/CT32: C432.1, U432.4 (CT)
/Power Rails/CT33: C433.1, U433.4 (CT)
/Power Rails/PWR_EN: R411.2, R412.1, SW401.2 (B), U411.2 (EN), U421.2 (EN)
/Power Rails/QD30: R430.1, U430.5 (QOD)
/Power Rails/QD31: R431.1, U431.5 (QOD)
/Power Rails/QD32: R432.1, U432.5 (QOD)
/Power Rails/QD33: R433.1, U433.5 (QOD)
EXP_EN_ETH: U431.3 (ON); also elsewhere on the board
EXP_EN_GPS: U432.3 (ON); also elsewhere on the board
EXP_EN_LCD: U430.3 (ON); also elsewhere on the board
EXP_EN_M1421: U433.3 (ON); also elsewhere on the board
GND: C411.2, C412.2, C413.2, C414.2, C416.2, C417.2, C421.2, C422.2, C423.2, C424.2, C426.2, C427.2, C430.2, C431.2, C432.2, C433.2, R412.2, R414.2, R424.2, SW401.3 (C), U411.4 (GND), U421.4 (GND), U430.2 (GND), U431.2 (GND), U432.2 (GND), U433.2 (GND); also elsewhere on the board
PM1_CH4_N: RS402.3; also elsewhere on the board
PM1_CH4_P: RS402.2; also elsewhere on the board
PM2_CH1_N: RS403.3; also elsewhere on the board
PM2_CH1_P: RS403.2; also elsewhere on the board
PM2_CH2_N: RS404.3; also elsewhere on the board
PM2_CH2_P: RS404.2; also elsewhere on the board
PM2_CH3_N: RS405.3; also elsewhere on the board
PM2_CH3_P: RS405.2; also elsewhere on the board
PM2_CH4_N: RS406.3; also elsewhere on the board
PM2_CH4_P: RS406.2; also elsewhere on the board
PM3_CH1_N: RS407.3; also elsewhere on the board
PM3_CH1_P: RS407.2; also elsewhere on the board
PM3_CH2_N: RS408.3; also elsewhere on the board
PM3_CH2_P: RS408.2; also elsewhere on the board
PM3_CH3_N: RS409.3; also elsewhere on the board
PM3_CH3_P: RS409.2; also elsewhere on the board
PM3_CH4_N: RS401.3; also elsewhere on the board
PM3_CH4_P: RS401.2; also elsewhere on the board
VSYS: C411.1, C412.1, C413.1, C421.1, C422.1, C423.1, R411.1, TP403.1, U411.3 (VIN), U421.3 (VIN); also elsewhere on the board

Notes on the sheet:
RAILS: two TPS62933 bucks from VSYS (5 V and 3V3, 3 A each), shared PWR_EN with UVLO ~5.5 V. Every branch has a Kelvin shunt (PAC1954 channel on its sense labels) that doubles as a bring-up link. TPS22917 load switches on 5V_LCD, 3V3_ETH, 3V3_GPS, 3V3_M1421 (enabled from the TCA6408A). 3V3_MCU feed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
POWER: SW401 OFF = PWR_EN low = both bucks off. VSYS, charger and VBACKUP stay alive.

Schematic: usb_host.kicad_sch, ADSB_Test - USB Host

Parts:
C1101: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C1102: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C1103: 150uF 10V; CP_Elec_6.3x5.8
C1104: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J1101: USB-A (SDR hub); USB_A_Wuerth_614004134726_Horizontal
R1101: 604R 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1102: 402k 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1103: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1104: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1101: VBUS_HOST; TestPoint_Pad_D1.5mm
TP1102: USBA_FAULT; TestPoint_Pad_D1.5mm
U1101: TPS259621DDA; TI_SO-PowerPAD-8_ThermalVias
U1102: USBLC6-2SC6; SOT-23-6_Handsoldering

Connections:
3V3: R1103.1; also elsewhere on the board
5V_SDR: C1102.1, U1101.4 (VIN); also elsewhere on the board
/USB Host/USBA_DVDT: C1101.1, U1101.2 (dV/dT)
/USB Host/USBA_ILM: R1101.1, U1101.7 (ILM)
/USB Host/USBA_OVC: R1102.1, U1101.8 (OVLO/OVCSEL)
EXP_USBA_EN: R1104.1, U1101.3 (EN/UVLO); also elsewhere on the board
GND: C1101.2, C1102.2, C1103.2, C1104.2, J1101.4 (GND), J1101.SH (Shield), R1101.2, R1102.2, R1104.2, U1101.1 (GND), U1101.9 (GND), U1102.2 (GND); also elsewhere on the board
USBA_FAULT: R1103.2, TP1102.1, U1101.6 (~FLT); also elsewhere on the board
USB_HS_D_N: J1101.2 (D-), U1102.3 (I/O2), U1102.4 (I/O2); also elsewhere on the board
USB_HS_D_P: J1101.3 (D+), U1102.1 (I/O1), U1102.6 (I/O1); also elsewhere on the board
VBUS_HOST: C1103.1, C1104.1, J1101.1 (VBUS), TP1101.1, U1101.5 (OUT), U1102.5 (VBUS)

Notes on the sheet:
USB HOST: P4 HS OTG (module pads 44/45) -> USBLC6 -> USB-A, 90R differential, short. VBUS: 5V_SDR (shunt RS402, PM1 CH4) -> TPS259621 eFuse (~1.5 A, 5.7 V clamp, dV/dt 10 nF) -> 150 uF. EN from the expander (EXP_USBA_EN, 100k pull-down: off at reset), FAULT (open drain) -> P4 GPIO27. PowerPAD: ther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

Schematic: m1421.kicad_sch, ADSB_Test - M1421

Parts:
C1401: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C1402: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1401: RED 1090; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1402: GREEN UAT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1403: ESD7351XV2T1G; D_SOD-523
J1401: m1421 JTAG (J-Link); PinHeader_2x05_P1.27mm_Vertical_SMD
J1402: ADSBee 1421 Dev Kit; PinHeader_1x06_P2.54mm_Vertical
J1403: SMA 1090/978; SMA_Samtec_SMA-J-P-H-ST-EM1_EdgeMount
R1401, R1402, R1403, R1404, R1405, R1409: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1406: 287R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1407: 115R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1408: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SH1401: RF can frame (DNP); Laird_Technologies_BMI-S-203-F_26.21x26.21mm; MPN Laird BMI-S-203-F frame + BMI-S-203-C l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; not fitted
TP1401: SD23; TestPoint_Pad_D1.5mm
TP1402: SD24; TestPoint_Pad_D1.5mm
TP1403: SD25; TestPoint_Pad_D1.5mm
TP1404: LD11; TestPoint_Pad_D1.5mm
TP1405: LD09; TestPoint_Pad_D1.5mm
TP1406: LD08; TestPoint_Pad_D1.5mm
TP1407: LRST; TestPoint_Pad_D1.5mm
TP1408: CSMI; TestPoint_Pad_D1.5mm
TP1409: CSMO; TestPoint_Pad_D1.5mm
TP1410: CSCK; TestPoint_Pad_D1.5mm
TP1411: LRCS; TestPoint_Pad_D1.5mm
TP1412: LBSY; TestPoint_Pad_D1.5mm
U1401: ADSBee m1421; PantsForBirds_ADSBee_m1421_Module_HandSolder
U1402: 74LVC1G97 (AND); SOT-23-6_Handsoldering
U1403: 74LVC1G32; SOT-23-5_HandSoldering
U1404: 74LVC1G07; SOT-23-5_HandSoldering
U1405: SCN-2-11+; MiniCircuits_SCN

Connections:
3V3_M1421: C1401.1, C1402.1, J1401.1 (VTref), J1402.1, R1401.1, R1404.1, R1405.1, R1409.1, U1401.1 (VCC), U1401.4 (VCC), U1401.19 (VCC), U1401.22 (VCC), U1402.5 (VCC), U1403.5 (VCC), U1404.5 (VCC); also elsewhere on the board
/M1421/LED_SD26_A: D1401.2 (A), R1406.2
/M1421/LED_SD27_A: D1402.2 (A), R1407.2
/M1421/M1421_CSCK: TP1410.1, U1401.31 (COPRO_SPI_CLK)
/M1421/M1421_CSMI: TP1408.1, U1401.29 (COPRO_SPI_MISO)
/M1421/M1421_CSMO: TP1409.1, U1401.30 (COPRO_SPI_MOSI)
/M1421/M1421_LBSY: TP1412.1, U1401.33 (LR_BUSY)
/M1421/M1421_LD08: TP1406.1, U1401.5 (LR_DIO8)
/M1421/M1421_LD09: TP1405.1, U1401.3 (LR_DIO9)
/M1421/M1421_LD11: TP1404.1, U1401.2 (LR_DIO11)
/M1421/M1421_LRCS: TP1411.1, U1401.32 (~LR_CS)
/M1421/M1421_LRST: TP1407.1, U1401.7 (~LR_RESET)
/M1421/M1421_RF_978: R1408.2, U1401.24 (SUBG_RF), U1405.6 (P1)
/M1421/M1421_RF_1090: R1408.1, U1401.26 (LR_RF_LF), U1405.4 (P2)
/M1421/M1421_SD23: TP1401.1, U1401.12 (SUBG_DIO23)
/M1421/M1421_SD24: TP1402.1, U1401.13 (SUBG_DIO24)
/M1421/M1421_SD25: TP1403.1, U1401.14 (SUBG_DIO25)
/M1421/M1421_TCKC: J1401.4 (SWCLK/TCK), U1401.9 (JTAG_TCKC)
/M1421/M1421_TDI: J1401.8 (NC/TDI), U1401.11 (JTAG_TDI)
/M1421/M1421_TDO: J1401.6 (SWO/TDO), U1401.10 (JTAG_TDO)
/M1421/M1421_TMSC: J1401.2 (SWDIO/TMS), U1401.8 (JTAG_TMSC)
/M1421/RF_ADSB_ANT: D1403.1 (A1), J1403.1 (In), U1405.2 (SUM)
DEV_M1421_NRST: R1404.2, U1404.2; also elsewhere on the board
DEV_M1421_SYNC: R1403.1, U1403.2; also elsewhere on the board
DEV_M1421_TX: R1401.2, U1402.3 (IN0); also elsewhere on the board
GND: C1401.2, C1402.2, D1401.1 (K), D1402.1 (K), D1403.2 (A2), J1401.3 (GND), J1401.5 (GND), J1401.9 (GNDDetect), J1402.6, J1403.2 (Ext), R1402.2, R1403.2, SH1401.1, U1401.6 (GND), U1401.18 (GND), U1401.23 (GND), U1401.25 (GND), U1401.27 (GND), U1401.34 (GND), U1401.36 (GND), U1401.MP, U1402.1 (IN1), U1402.2 (GND), U1403.3 (GND), U1404.3 (GND), U1405.1 (GND), U1405.3 (GND), U1405.5 (GND); also elsewhere on the board
M1421_NRST: J1401.10 (~RESET), J1402.5, R1405.2, U1401.17 (~SUBG_RESET), U1404.4; also elsewhere on the board
M1421_SD26: R1406.1, U1401.15 (SUBG_DIO26); also elsewhere on the board
M1421_SD27: R1407.1, U1401.16 (SUBG_DIO27); also elsewhere on the board
M1421_SURX: J1402.2, U1401.20 (SUBG_UART_RX), U1402.4 (Y); also elsewhere on the board
M1421_SUTX: J1402.3, U1401.21 (SUBG_UART_TX); also elsewhere on the board
M1421_SYNC: J1402.4, R1402.1, U1401.28 (SYNC), U1403.4; also elsewhere on the board
P4_M1421_SYNC: U1403.1; also elsewhere on the board
P4_M1421_TX: R1409.2, U1402.6 (IN2); also elsewhere on the board

Notes on the sheet:
FIT OPTIONS: solder U1401 (m1421), or leave it off and plug the ADSBee 1421 Dev Kit into J1402 (JST-GH harness, own antenna). SYNC (pad 28) is an INPUT: high at reset = ROM bootloader, high at run time = sleep. SURX = P4 TX AND Dev TX (U1402). M1421_NRST: TCA6408A bit 7 (open-drain style), U1404 fo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

Schematic: test_debug.kicad_sch, ADSB_Test - Test Debug

Parts:
H1601, H1602, H1603, H1604: M2.5; MountingHole_2.7mm_M2.5_Pad_Via
J1601: Kingst LA5016 (2x20 keyed); IDC-Header_2x20_P2.54mm_Vertical
R1601, R1602, R1603, R1604, R1605, R1606, R1607, R1608, R1609, R1610, R1611, R1612, R1613, R1614, R1615, R1616: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1617: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; not fitted
TP1601: LA_PWM1; TestPoint_Pad_D1.5mm
TP1602: LA_PWM2; TestPoint_Pad_D1.5mm
TP1603, TP1604, TP1605, TP1606: GND; TestPoint_Pad_D1.5mm

Connections:
/Test Debug/LA_CH0: J1601.1, R1601.2
/Test Debug/LA_CH1: J1601.3, R1602.2
/Test Debug/LA_CH2: J1601.5, R1603.2
/Test Debug/LA_CH3: J1601.7, R1604.2
/Test Debug/LA_CH4: J1601.9, R1605.2
/Test Debug/LA_CH5: J1601.11, R1606.2
/Test Debug/LA_CH6: J1601.13, R1607.2
/Test Debug/LA_CH7: J1601.15, R1608.2
/Test Debug/LA_CH8: J1601.19, R1609.2
/Test Debug/LA_CH9: J1601.21, R1610.2
/Test Debug/LA_CH10: J1601.23, R1611.2
/Test Debug/LA_CH11: J1601.25, R1612.2
/Test Debug/LA_CH12: J1601.27, R1613.2
/Test Debug/LA_CH13: J1601.29, R1614.2
/Test Debug/LA_CH14: J1601.31, R1615.2
/Test Debug/LA_CH15: J1601.33, R1616.2
/Test Debug/LA_PWM1: J1601.37, R1617.1, TP1601.1
/Test Debug/LA_PWM2: J1601.39, TP1602.1
C5_CON_TX: R1610.1; also elsewhere on the board
CHG_PD_INT: R1614.1; also elsewhere on the board
DBG_A: R1615.1; also elsewhere on the board
DBG_B: R1616.1; also elsewhere on the board
GND: H1601.1, H1602.1, H1603.1, H1604.1, J1601.17, J1601.18, J1601.35, J1601.36, TP1603.1, TP1604.1, TP1605.1, TP1606.1; also elsewhere on the board
GPS_PPS: R1603.1, R1617.2; also elsewhere on the board
GPS_TX: R1604.1; also elsewhere on the board
I2C_SCL: R1601.1; also elsewhere on the board
I2C_SDA: R1602.1; also elsewhere on the board
M1421_SD26: R1608.1; also elsewhere on the board
M1421_SD27: R1612.1; also elsewhere on the board
M1421_SURX: R1606.1; also elsewhere on the board
M1421_SUTX: R1605.1; also elsewhere on the board
M1421_SYNC: R1607.1; also elsewhere on the board
P4_CON_TX: R1609.1; also elsewhere on the board
P4_USER_TX: R1611.1; also elsewhere on the board
PM_ALERT: R1613.1; also elsewhere on the board

Notes on the sheet:
LOGIC ANALYSER: Kingst LA5016 40-way cable into J1601. Key-side row (odd pins): 1-15 CH0-7, 17 GND, 19-33 CH8-15, 35 GND, 37 PWM1, 39 PWM2 (LA outputs). Even row reserved for the LA5032 (18/36 GND). CH: 0 SCL, 1 SDA, 2 GPS PPS, 3 GPS TX, 4 m1421 SUTX, 5 m1421 SURX, 6 SYNC, 7 SD26 | 8 P4 console TX,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

Schematic: mcu_module.kicad_sch, ADSB_Test - MCU Module

Parts:
C601, C602: 22uF 10V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C603, C608, C609: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C604, C607: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C605, C606: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J601: U.FL Wi-Fi (from module IPEX); U.FL_Hirose_U.FL-R-SMT-1_Vertical
J602: RP-SMA Wi-Fi 2.4/5 GHz; SMA_Molex_73251-3152_RP_EdgeMount; MPN Molex 0732513152 (RP-SMA, jam nut); foo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
R601: 10M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R602, R603: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R604: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R605, R607, R608: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R606: 330R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R609: 470R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW601: BOOT; SW_PUSH_6mm
SW602: RESET; SW_PUSH_6mm
SW603: SLEEP/WAKE; SW_Tactile_SPST_Angled_PTS645Vx31-2LFS
TP601: C5_IO27; TestPoint_Pad_D1.5mm
TP602: C5_IO25; TestPoint_Pad_D1.5mm
TP603: C5_IO24; TestPoint_Pad_D1.5mm
TP604: C5_IO23; TestPoint_Pad_D1.5mm
TP605: C5_IO6; TestPoint_Pad_D1.5mm
TP606: C5_IO5; TestPoint_Pad_D1.5mm
TP607: C5_IO4; TestPoint_Pad_D1.5mm
TP608: SLEEP_WAKE; TestPoint_Pad_D1.5mm
TP609: P4_GPIO20; TestPoint_Pad_D1.5mm
TP610: P4_GPIO36; TestPoint_Pad_D1.5mm
TP611: C5_PU; TestPoint_Pad_D1.5mm
U601: ESP32-P4C5 Core (OSPTEK); OSPTEK_ESP32-P4C5_Core_HandSolder
Y601: 32.768kHz; Crystal_C26-LF_D2.1mm_L6.5mm_Horizontal

Connections:
3V3: R602.1, R603.1, R604.1, R605.1; also elsewhere on the board
3V3_MCU: C601.1, C602.1, C603.1, R607.1, R608.1, U601.85 (ESP_3V3), U601.86 (ESP_3V3); also elsewhere on the board
/MCU Module/C5_IO4: TP607.1, U601.14 (C5_IO4)
/MCU Module/C5_IO5: TP606.1, U601.13 (C5_IO5)
/MCU Module/C5_IO6: TP605.1, U601.12 (C5_IO6)
/MCU Module/C5_IO23: TP604.1, U601.11 (C5_IO23)
/MCU Module/C5_IO24: TP603.1, U601.10 (C5_IO24)
/MCU Module/C5_IO25: TP602.1, U601.9 (C5_IO25)
/MCU Module/C5_IO26: R605.2, U601.8 (C5_IO26)
/MCU Module/C5_IO27: TP601.1, U601.7 (C5_IO27)
/MCU Module/C5_PU: R606.1, TP611.1, U601.82 (GPIO54/C5_CHIP_PU)
/MCU Module/P4_GPIO20: TP609.1, U601.29 (GPIO20)
/MCU Module/P4_GPIO36: TP610.1, U601.63 (GPIO36)
/MCU Module/SLEEP_BTN: R608.2, R609.1, SW603.1
/MCU Module/SLEEP_WAKE: C609.1, R609.2, TP608.1, U601.27 (GPIO12)
/MCU Module/WIFI_ANT: J601.1 (In), J602.1 (In)
/MCU Module/XTAL32_N: C606.1, R601.2, U601.88 (GPIO0/XTAL_32K_N), Y601.2
/MCU Module/XTAL32_P: C605.1, R601.1, U601.16 (GPIO1/XTAL_32K_P), Y601.1
C5_BOOT: U601.6 (C5_IO28/BOOT); also elsewhere on the board
C5_CON_RX: U601.4 (C5_U0RXD); also elsewhere on the board
C5_CON_TX: U601.5 (C5_U0TXD); also elsewhere on the board
C5_EN: R606.2; also elsewhere on the board
CHG_PD_INT: U601.24 (GPIO9); also elsewhere on the board
DBG_A: U601.25 (GPIO10); also elsewhere on the board
DBG_B: U601.26 (GPIO11); also elsewhere on the board
DSI_CLK_N: U601.36 (DSI_CLKN); also elsewhere on the board
DSI_CLK_P: U601.37 (DSI_CLKP); also elsewhere on the board
DSI_D0_N: U601.39 (DSI_D0N); also elsewhere on the board
DSI_D0_P: U601.38 (DSI_D0P); also elsewhere on the board
DSI_D1_N: U601.35 (DSI_D1N); also elsewhere on the board
DSI_D1_P: U601.34 (DSI_D1P); also elsewhere on the board
ETH_CRS_DV: U601.55 (GPIO28); also elsewhere on the board
ETH_MDC: U601.58 (GPIO31); also elsewhere on the board
ETH_MDIO: U601.80 (GPIO52); also elsewhere on the board
ETH_PHY_RST: U601.79 (GPIO51); also elsewhere on the board
ETH_REF_CLK: U601.78 (GPIO50); also elsewhere on the board
ETH_RXD0: U601.56 (GPIO29); also elsewhere on the board
ETH_RXD1: U601.57 (GPIO30); also elsewhere on the board
ETH_TXD0: U601.61 (GPIO34); also elsewhere on the board
ETH_TXD1_BOOT: R604.2, SW601.1, U601.62 (GPIO35/BOOT); also elsewhere on the board
ETH_TX_EN: U601.77 (GPIO49); also elsewhere on the board
EXP_INT: U601.81 (GPIO53); also elsewhere on the board
GND: C601.2, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, C609.2, J601.2 (Ext), J602.2 (Ext), SW601.2, SW602.2, SW603.2, U601.1 (GND), U601.3 (GND), U601.15 (GND), U601.33 (GND), U601.40 (GND), U601.47 (GND), U601.52 (GND), U601.83 (GND); also elsewhere on the board
GPS_PPS: U601.19 (GPIO4); also elsewhere on the board
GPS_TX: U601.18 (GPIO3); also elsewhere on the board
I2C_SCL: R603.2, U601.23 (GPIO8); also elsewhere on the board
I2C_SDA: R602.2, U601.22 (GPIO7); also elsewhere on the board
LCD_BL_PWM: U601.59 (GPIO32); also elsewhere on the board
LCD_RST: U601.60 (GPIO33); also elsewhere on the board
M1421_SUTX: U601.75 (GPIO47); also elsewhere on the board
P4_CON_RX: U601.65 (GPIO38/U0RXD); also elsewhere on the board
P4_CON_TX: U601.64 (GPIO37/U0TXD); also elsewhere on the board
P4_EN: C607.1, R607.2, SW602.1, U601.87 (CHIP_PU); also elsewhere on the board
P4_GPS_TX: U601.17 (GPIO2); also elsewhere on the board
P4_M1421_SYNC: U601.76 (GPIO48); also elsewhere on the board
P4_M1421_TX: U601.74 (GPIO46); also elsewhere on the board
P4_USER_RX: U601.31 (GPIO22); also elsewhere on the board
P4_USER_TX: U601.30 (GPIO21); also elsewhere on the board
P4_USJ_D_N: U601.50 (GPIO24/USB_JTAG_N); also elsewhere on the board
P4_USJ_D_P: U601.51 (GPIO25/USB_JTAG_P); also elsewhere on the board
PM_ALERT: U601.20 (GPIO5); also elsewhere on the board
RTC_INT: U601.28 (GPIO13); also elsewhere on the board
SD_CLK: U601.71 (GPIO43); also elsewhere on the board
SD_CMD: U601.72 (GPIO44); also elsewhere on the board
SD_D0: U601.67 (GPIO39); also elsewhere on the board
SD_D1: U601.68 (GPIO40); also elsewhere on the board
SD_D2: U601.69 (GPIO41); also elsewhere on the board
SD_D3: U601.70 (GPIO42); also elsewhere on the board
SD_PWR_EN: U601.73 (GPIO45); also elsewhere on the board
SD_VIO: C604.1, U601.66 (ESP_LDO_VO4); also elsewhere on the board
TOUCH_INT: U601.53 (GPIO26); also elsewhere on the board
TOUCH_RST: U601.32 (GPIO23); also elsewhere on the board
USBA_FAULT: U601.54 (GPIO27); also elsewhere on the board
USB_HS_D_N: U601.48 (USB_DM); also elsewhere on the board
USB_HS_D_P: U601.49 (USB_DP); also elsewhere on the board
VBACKUP: C608.1, U601.84 (RTC_VBAT); also elsewhere on the board

Notes on the sheet:
MCU MODULE: OSPTEK ESP32-P4C5 Core (ESP32-P4 rev v3.x + ESP32-C5HF4, 16 MB flash, 32 MB PSRAM). Inside the module: SDIO on P4 GPIO14-19, C5 CHIP_PU = P4 GPIO54 (pad 82), C5 GPIO2 = P4 GPIO6 (pad 21, NC here) - the same wiring as the Waveshare reference board. Pins: bsp/include/bsp/board_pins.h. 3.3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

Board: 4 copper layers, 502 parts (502 on the bottom side), 397 nets, no tracks yet.

File boards/adsb-test/hardware/bom/ADSB_Test_BOM.csv (part):

line,qty,refs,value,footprint,dnp,manufacturer,mpn,supplier,supplier_pn,order_link,unit_usd,ext_usd,stock_2026_10_12,uk_stock,notes,Mouser UK,Farnell UK,RS UK
1,1,U201,STUSB4500QTR,QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm_HandSolder,,STMicroelectronics,STUSB4500QTR,DigiKey,497-18060-1-ND,https://www.digikey.com/en/products/result?keywords=STUSB4500QTR,2.22,2.22,27k,,,https://www.mouser.co.uk/c/?q=STUSB4500QTR,https://uk.farnell.com/search?st=STUSB4500QTR,https://uk.rs-online.com/web/c/?searchTerm=STUSB4500QTR
2,1,U301,BQ25798,Texas_RQM0029A_VQFN-29_4x4mm_P0.4mm,,Texas Instruments,BQ25798RQMR,DigiKey,296-BQ25798RQMRCT-ND,https://www.digikey.com/en/products/result?keywords=BQ25798RQMR,5.90,5.90,7.3k,,,https://www.mouser.co.uk/c/?q=BQ25798RQMR,https://uk.farnell.com/search?st=BQ25798RQMR,https://uk.rs-online.com/web/c/?searchTerm=BQ25798RQMR
3,1,U302,MCP1703 3.0V (2 uA Iq),SOT-23_Handsoldering,,Microchip,MCP1703T-3002E/CB,DigiKey,MCP1703T-3002E/CBCT-ND,https://www.digikey.com/en/products/result?keywords=MCP1703T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,0.75,0.75,5.1k,,,https://www.mouser.co.uk/c/?q=MCP1703T-3002E/CB,https://uk.farnell.com/search?st=MCP1703T-3002E/CB,https://uk.rs-online.com/web/c/?searchTerm=MCP1703T-3002E/CB
4,2,U411 U421,TPS62933,SOT-583-8_HandSolder,,Texas Instruments,TPS62933DRLR,DigiKey,296-TPS62933DRLRCT-ND,https://www.digikey.com/en/products/result?keywords=TPS62933DRLR,1.60,3.20,64k,,,https://www.mouser.co.uk/c/?q=TPS62933DRLR,https://uk.farnell.com/search?st=TPS62933DRLR,https://uk.rs-online.com/web/c/?searchTerm=TPS62933DRLR
5,4,U430 U431 U432 U433,TPS22917,SOT-23-6_Handsoldering,,Texas Instruments,TPS22917DBVR,DigiKey,296-50498-1-ND,https://www.digikey.com/en/products/result?keywords=TPS22917DBVR,0.55,2.20,72k,,,https://www.mouser.co.uk/c/?q=TPS22917DBVR,https://uk.farnell.com/search?st=TPS22917DBVR,https://uk.rs-online.com/web/c/?searchTerm=TPS22917DBVR
6,1,U501,PAC1954 (PM1),VQFN-16-1EP_3x3mm_P0.5mm_EP1.1x1.1mm_HandSolder,,Microchip,PAC1954T-E/4MX,DigiKey,150-PAC1954T-E/4MXCT-ND,https://www.digikey.com/en/products/result?keywords=PAC1954T-E/4MX,2.02,2.02,10k,,,https://www.mouser.co.uk/c/?q=PAC1954T-E/4MX,https://uk.farnell.com/search?st=PAC1954T-E/4MX,https://uk.rs-online.com/web/c/?searchTerm=PAC1954T-E/4MX
7,1,U502,PAC1954 (PM2),VQFN-16-1EP_3x3mm_P0.5mm_EP1.1x1.1mm_HandSolder,,Microchip,PAC1954T-E/4MX,DigiKey,150-PAC1954T-E/4MXCT-ND,https://www.digikey.com/en/products/result?keywords=PAC1954T-E/4MX,2.02,2.02,10k,,,https://www.mouser.co.uk/c/?q=PAC1954T-E/4MX,https://uk.farnell.com/search?st=PAC1954T-E/4MX,https://uk.rs-online.com/web/c/?searchTerm=PAC1954T-E/4MX
8,1,U503,PAC1954 (PM3),VQFN-16-1EP_3x3mm_P0.5mm_EP1.1x1.1mm_HandSolder,,Microchip,PAC1954T-E/4MX,DigiKey,150-PAC1954T-E/4MXCT-ND,https://www.digikey.com/en/products/result?keywords=PAC1954T-E/4MX,2.02,2.02,10k,,,https://www.mouser.co.uk/c/?q=PAC1954T-E/4MX,https://uk.farnell.com/search?st=PAC1954T-E/4MX,https://uk.rs-online.com/web/c/?searchTerm=PAC1954T-E/4MX
9,1,U601,ESP32-P4C5 Core (OSPTEK),OSPTEK_ESP32-P4C5_Core_HandSolder,,OSPTEK,ESP32-P4C5 Core module,AliExpress (OSPTEK),https://www.aliexpress.com/item/1005012626312933.html,https://www.aliexpress.com/item/1005012626312933.html,16.50,16.50,,,about GBP 13 (user 2026-10-12); docs github.com/osptek/esp32-p4c5-core-board,,,
10,1,U801,LAN8720A,VQFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm_HandSolder,,Microchip,LAN8720A-CP-TR,DigiKey,LAN8720A-CP-CT-ND,https://www.digikey.com/en/products/result?keywords=LAN8720A-CP-TR,1.03,1.03,35k,,,https://www.mouser.co.uk/c/?q=LAN8720A-CP-TR,https://uk.farnell.com/search?st=LAN8720A-CP-TR,https://uk.rs-online.com/web/c/?searchTerm=LAN8720A-CP-TR
11,1,U901,CP2102N-A02-GQFN24,QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_HandSolder,,Silicon Labs,CP2102N-A02-GQFN24R,DigiKey,336-5888-1-ND,https://www.digikey.com/en/products/result?keywords=CP2102N-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,5.46,5.46,10.9k,,,https://www.mouser.co.uk/c/?q=CP2102N-A02-GQFN24R,https://uk.farnell.com/search?st=CP2102N-A02-GQFN24R,https://uk.rs-online.com/web/c/?searchTerm=CP2102N-A02-GQFN24R
12,3,U902 U1001 U1102,USBLC6-2SC6,SOT-23-6_Handsoldering,,STMicroelectronics,USBLC6-2SC6,DigiKey,497-5235-1-ND,https://www.digikey.com/en/products/result?keywords=USBLC6-2SC6,0.54,1.62,127k,,,https://www.mouser.co.uk/c/?q=USBLC6-2SC6,https://uk.farnell.com/search?st=USBLC6-2SC6,https://uk.rs-online.com/web/c/?searchTerm=USBLC6-2SC6
13,1,U1002,AP2112K-3.3,SOT-23-5_HandSoldering,,Diodes Inc,AP2112K-3.3TRG1,DigiKey,AP2112K-3.3TRG1DICT-ND,https://www.digikey.com/en/products/result?keywords=AP2112K-3.3TRG1,0.28,0.28,431k,,,https://www.mouser.co.uk/c/?q=AP2112K-3.3TRG1,https://uk.farnell.com/search?st=AP2112K-3.3TRG1,https://uk.rs-online.com/web/c/?searchTerm=AP2112K-3.3TRG1
14,1,U1003,USB2514B,QFN-36-1EP_6x6mm_P0.5mm_EP3.7x3.7mm_HandSolder,,Microchip,USB2514B-AEZC-TR,DigiKey,USB2514B-AEZC-CT-ND,https://www.digikey.com/en/products/result?keywords=USB2514B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,2.49,2.49,14k,,,https://www.mouser.co.uk/c/?q=USB2514B-AEZC-TR,https://uk.farnell.com/search?st=USB2514B-AEZC-TR,https://uk.rs-online.com/web/c/?searchTerm=USB2514B-AEZC-TR
15,1,U1101,TPS259621DDA,TI_SO-PowerPAD-8_ThermalVias,,Texas Instruments,TPS259621DDAR,DigiKey,296-TPS259621DDARCT-ND,https://www.digikey.com/en/products/result?keywords=TPS259621DDAR,1.07,1.07,1.1k,,,https://www.mouser.co.uk/c/?q=TPS259621DDAR,https://uk.farnell.com/search?st=TPS259621DDAR,https://uk.rs-online.com/web/c/?searchTerm=TPS259621DDAR
16,1,U1201,MAX-M10S,ublox_MAX,,u-blox,MAX-M10S-00B,DigiKey,672-MAX-M10S-00BCT-ND,https://www.digikey.com/en/products/result?keywords=MAX-M10S-00B,11.42,11.42,4.2k,,,https://www.mouser.co.uk/c/?q=MAX-M10S-00B,https://uk.farnell.com/search?st=MAX-M10S-00B,https://uk.rs-online.com/web/c/?searchTerm=MAX-M10S-00B
17,1,U1301,AP3012KTR-E1,SOT-23-5_HandSoldering,,Diodes Inc,AP3012KTR-E1,DigiKey,AP3012KTR-E1DICT-ND,https://www.digikey.com/en/products/result?keywords=AP3012KTR-E1,0.64,0.64,440,,,https://www.mouser.co.uk/c/?q=AP3012KTR-E1,https://uk.farnell.com/search?st=AP3012KTR-E1,https://uk.rs-online.com/web/c/?searchTerm=AP3012KTR-E1
18,1,U1302,AP2112K-1.8,SOT-23-5_HandSoldering,,Diodes Inc,AP2112K-1.8TRG1,DigiKey,AP2112K-1.8TRG1DICT-ND,https://www.digikey.com/en/products/result?keywords=AP2112K-1.8TRG1,0.27,0.27,100k,,,https://www.mouser.co.uk/c/?q=AP2112K-1.8TRG1,https://uk.farnell.com/search?st=AP2112K-1.8TRG1,https://uk.rs-online.com/web/c/?searchTerm=AP2112K-1.8TRG1
19,1,U1303,AP3032KTR-G1,SOT-23-6_Handsoldering,,Diodes Inc,AP3032KTR-G1,DigiKey,AP3032KTR-G1DICT-ND,https://www.digikey.com/en/products/result?keywords=AP3032KTR-G1,0.31,0.31,15,,low stock - order early,https://www.mouser.co.uk/c/?q=AP3032KTR-G1,https://uk.farnell.com/search?st=AP3032KTR-G1,https://uk.rs-online.com/web/c/?searchTerm=AP3032KTR-G1
20,1,U1401,ADSBee m1421,PantsForBirds_ADSBee_m1421_Module_HandSolder,,Pants for Birds,ADSBee m1421,Pants for Birds,https://pantsforbirds.com/adsbee/dual-band-module/,https://pantsforbirds.com/adsbee/dual-band-module/,,,,,Or start with the ADSBee 1421 Dev Kit on J1402,,,
21,1,U1402,74LVC1G97 (AND),SOT-23-6_Handsoldering,,Texas Instruments,SN74LVC1G97DBVR,DigiKey,296-15581-1-ND,https://www.digikey.com/en/products/result?keywords=SN74LVC1G97DBVR,0.23,0.23,24k,,,https://www.mouser.co.uk/c/?q=SN74LVC1G97DBVR,https://uk.farnell.com/search?st=SN74LVC1G97DBVR,https://uk.rs-online.com/web/c/?searchTerm=SN74LVC1G97DBVR
22,1,U1403,74LVC1G32,SOT-23-5_HandSoldering,,Texas Instruments,SN74LVC1G32DBVR,DigiKey,296-9847-1-ND,https://www.digikey.com/en/products/result?keywords=SN74LVC1G32DBVR,0.12,0.12,1.4k,,,https://www.mouser.co.uk/c/?q=SN74LVC1G32DBVR,https://uk.farnell.com/search?st=SN74LVC1G32DBVR,https://uk.rs-online.com/web/c/?searchTerm=SN74LVC1G32DBVR
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